# Repository AquaBeacon/hardware (continued)

## KiCad design pcb/CHILD_PWR/CHILD_PWR.kicad_pcb (continued)

Board: 2 copper layers, 62.0 x 70.0 mm, 33 parts (0 on the bottom side), 17 nets.

## KiCad design pcb/CHILD_MAIN/CHILD_MAIN.kicad_pcb

Parts:
C_BNO: 100n; C_0603_1608Metric
C_D1, C_D2: 100n; C_0603_1608Metric
C_LCD: 100n; C_0603_1608Metric
C_LEAK: 10n; C_0603_1608Metric
C_RST: 100n; C_0603_1608Metric
C_SD1: 100n; C_0603_1608Metric
C_SD2: 10u; C_0805_2012Metric
C_THP: 100n; C_0603_1608Metric
C_V3, C_V5: 10u; C_0805_2012Metric
C_V3A, C_V3b, C_V5b: 100n; C_0603_1608Metric
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J_BNO1: BNO085_4754; Adafruit_BNO085_4754
J_LCD1: NHD_C0216CiZ; JST_XH_B7B-XH-A_1x07_P2.50mm_Vertical
J_LEAK1: LEAK; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J_PRS1: MS5837; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J_PWR1: FROM_CPWR; JST_XH_B9B-XH-A_1x09_P2.50mm_Vertical
J_RTC1: DS3231_ZS042
J_RX1: TO_CRX; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J_TEMP1: CELSIUS_TSYS01; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J_TETH1: TETHER; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
LED_PWR: GREEN; LED_0805_2012Metric
LED_ST: RED; LED_0805_2012Metric
PICO1: Pico 2 W; RaspberryPi_Pico_Common_THT
Q_BL: 2N7002; SOT-23
R_AL: 10k; R_0603_1608Metric
R_BL: 100; R_0603_1608Metric
R_CD: 47k; R_0603_1608Metric
R_D: 10k; R_0603_1608Metric
R_E: 3.3k; R_0603_1608Metric
R_G: 100; R_0603_1608Metric
R_GPD: 100k; R_0603_1608Metric
R_LAD: 10k; R_0603_1608Metric
R_LEAK: 100k; R_0603_1608Metric
R_PWR: 1k; R_0603_1608Metric
R_RST: 10k; R_0603_1608Metric
R_SCL: 4.7k_DNP; R_0603_1608Metric
R_SDA: 4.7k_DNP; R_0603_1608Metric
R_SDCS: 10k; R_0603_1608Metric
R_ST: 1k; R_0603_1608Metric
R_THP: 1k; R_0603_1608Metric
R_TRMD1: 120_DNP; R_0603_1608Metric
SD1: microSD; microSD_TF-01A
SW_DN: DOWN; SW_PUSH_6mm
SW_ENT: ENTER; SW_PUSH_6mm
SW_UP: UP; SW_PUSH_6mm
TP_GND1: GND; TestPoint_THTPad_D1.5mm_Drill0.7mm
U_485D1: W_RS485_DATA; Waveshare_TTL_RS485_C

Connections:
485D_A: J_TETH1.1, R_TRMD1.1, U_485D1.7
485D_B: J_TETH1.2, R_TRMD1.2, U_485D1.6
485D_PE: J_TETH1.3, U_485D1.5
485D_RXD: PICO1.2 (GPIO1), U_485D1.3
485D_TXD: PICO1.1 (GPIO0), U_485D1.2
BL_GATE: Q_BL.1 (G), R_G.2, R_GPD.1
BL_PWM: PICO1.34 (GPIO28_ADC2), R_G.1
BNO_CS: J_BNO1.12, PICO1.22 (GPIO17)
BNO_INT: J_BNO1.6, PICO1.26 (GPIO20)
BNO_MISO: J_BNO1.5, PICO1.21 (GPIO16)
BNO_MOSI: J_BNO1.11, PICO1.25 (GPIO19)
BNO_RST: J_BNO1.10, PICO1.27 (GPIO21)
BNO_SCK: J_BNO1.4, PICO1.24 (GPIO18)
BTN_ADC: PICO1.32 (GPIO27_ADC1), R_LAD.2, SW_DN.1, SW_ENT.1, SW_UP.1
CMP_OUT: J_RX1.6, PICO1.4 (GPIO2)
ENV_ADC: J_RX1.4, PICO1.31 (GPIO26_ADC0)
GND: C_BNO.2, C_D1.2, C_D2.2, C_LCD.2, C_LEAK.2, C_RST.2, C_SD1.2, C_SD2.2, C_THP.2, C_V3.2, C_V3A.2, C_V3b.2, C_V5.2, C_V5b.2, J_BNO1.3, J_LCD1.1, J_LEAK1.2, J_PRS1.2, J_PWR1.4, J_PWR1.7, J_RTC1.6, J_RX1.2, J_TEMP1.2, LED_PWR.1 (K), LED_ST.1 (K), PICO1.3 (GND), PICO1.8 (GND), PICO1.13 (GND), PICO1.18 (GND), PICO1.23 (GND), PICO1.28 (GND), PICO1.33 (AGND), PICO1.38 (GND), Q_BL.2 (S), R_D.2, R_E.2, R_GPD.2, SD1.6 (VSS), SD1.9 (DET_B), SD1.SH (SHIELD), SW_UP.2, TP_GND1.1, U_485D1.1
I2C_SCL: J_LCD1.4, J_PRS1.4, J_PWR1.5, J_RTC1.3, J_TEMP1.4, PICO1.7 (GPIO5), R_SCL.2
I2C_SDA: J_LCD1.3, J_PRS1.3, J_PWR1.6, J_RTC1.4, J_TEMP1.3, PICO1.6 (GPIO4), R_SDA.2
INA_AL: J_PWR1.8, PICO1.5 (GPIO3), R_AL.2
LCD_RST: C_RST.1, J_LCD1.5, R_RST.2
LEAK: C_LEAK.1, J_LEAK1.1, PICO1.29 (GPIO22), R_LEAK.2
LEDBL_A: J_LCD1.6, R_BL.2
LEDBL_K: J_LCD1.7, Q_BL.3 (D)
LEDP_A: LED_PWR.2 (A), R_PWR.2
LEDS_A: LED_ST.2 (A), R_ST.2
LED_STATUS: PICO1.19 (GPIO14), R_ST.1
LIGHT_PWM: J_PWR1.9, PICO1.11 (GPIO8)
N_D: R_D.1, SW_DN.2
N_E: R_E.1, SW_ENT.2
SD_CD: PICO1.20 (GPIO15), R_CD.2, SD1.10 (DET_A)
SD_CS: PICO1.17 (GPIO13), R_SDCS.2, SD1.2 (DAT3/CD)
SPI_MISO: PICO1.16 (GPIO12), SD1.7 (DAT0)
SPI_MOSI: PICO1.15 (GPIO11), SD1.3 (CMD)
SPI_SCK: PICO1.14 (GPIO10), SD1.5 (CLK)
TH_PWM: PICO1.9 (GPIO6), R_THP.1
TH_PWM_F: C_THP.1, J_RX1.3, R_THP.2
V3A: C_V3A.1, J_PWR1.3, J_RX1.1
V3D: C_BNO.1, C_D1.1, C_LCD.1, C_SD1.1, C_SD2.1, C_V3.1, C_V3b.1, J_BNO1.1, J_BNO1.8, J_BNO1.9, J_LCD1.2, J_PRS1.1, J_PWR1.2, J_RTC1.5, J_TEMP1.1, R_AL.1, R_CD.1, R_LAD.1, R_LEAK.1, R_PWR.1, R_RST.1, R_SCL.1, R_SDA.1, R_SDCS.1, SD1.4 (VDD), U_485D1.4
V5D: C_D2.1, C_V5.1, C_V5b.1, J_PWR1.1, PICO1.39 (VSYS), R_BL.1

Notes on the sheet:
POWER IN from C-PWR (XH9) / BULK / LED
MCU Raspberry Pi Pico 2 W
microSD TF-01A (SPI1)
RS485 DATA Waveshare SS-9778 (isolated)
I2C RTC DS3231(0x68) / PRS MS5837(0x76) / TEMP TSYS01(0x77)
DESIGN NOTES
UI LCD NHD-C0216CiZ(I2C 0x3E) / BACKLIGHT / 3-BUTTON ADC
TO C-RX (RX_improved_mini J2) / LEAK DETECT
IMU BNO085 Adafruit 4754 (SPI0)
RS485 側 GND/PE は基板 GND と分離 (絶縁を活かす)。PE はテザーへ
LCD 昇圧C (VOUT-VDD / C1+-C1- 各1u) は LCD 至近の
キャリア基板側に置く (充電ポンプノードなので XH で引き回さない)
BTN_ADC: UP=0V / ENT=0.82V / DN=1.65V / 無押下=3.3V
[1] 基板間
J_PWR1 = C-PWR J_MAIN と同一ピン順 (ストレート9芯1本)
I2C対(5/6) を GND(4/7) で挟み、LIGHT_PWM(9) を電源ピンから離してある
J_RX1 = 製造済み RX_improved_mini の J2 と同一ピン順 (pin5 は RX 側 NC)
[2] プルアップ / DNP
R_SDA/R_SCL (4.7k) は既定 DNP。組立後に SDA/SCL-V3D 間を実測して要否を決める
バスは 2 基板 + 4 ケーブルに跨るので、総容量が大きければ 2.2k も検討 (tr<1us)
R_SDCS: 起動時 Pico GPIO は Hi-Z -> CS フロート防止 (v4.3)
[3] 信号
R_THP+C_THP: 125kHz TH_PWM の dv/dt を落とし、隣接する ENV_ADC へのクロストークを抑える
(RX 側 VTH は高インピーダンス = 直列 R_THP による DC 誤差はゼロ)

Board: 2 copper layers, 104.0 x 88.0 mm, 54 parts (0 on the bottom side), 40 nets.

## KiCad design pcb/TX_improved/TX_improved.kicad_pcb

Board: 2 copper layers, 74.0 x 50.0 mm, 28 parts (0 on the bottom side), 11 nets.

Parts:
C1: 470u/25V; CP_Radial_D10.0mm_P5.00mm
C2, C3, C5: 100n; C_Disc_D5.0mm_W2.5mm_P5.00mm
C4: 10u; C_Disc_D5.0mm_W2.5mm_P5.00mm
C6: 1n DNP; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1: SMBJ48A; D_SMB
D2: GDZJ15C; D_DO-35_SOD27_P7.62mm_Horizontal
D3: SMBJ15A; D_SMB
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1: 12V_IN; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J2: PWM_IN; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J3: TD04A; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
J4: NTC_TH1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J5: TEMP_OUT; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
L1: 470uH; L_Radial_D10.0mm_P5.00mm_Fastron_07M
Q1: 2SK4017; TO-251-3_Vertical
R1: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R5: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6: 10k 1%; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R7: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
U1: TC4427; DIP-8_W7.62mm

Connections:
DRAIN: D1.1, L1.2, Q1.2, R3.1
GATE: D2.1, Q1.1, R2.1, R5.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D1.2, D2.2, D3.2, J1.1, J2.2, J3.2, J4.2, J5.2, Q1.3, R2.2, R4.2, U1.3, U1.4
INA: R1.2, U1.2
OUTA: R5.1, U1.7
PWM_IN: J2.1, R1.1
TEMP_ADC: C6.1, J5.3, R7.2
TEMP_RAW: C5.1, J4.1, R6.2, R7.1
V3S: J5.1, R6.1
V12: C1.1, C2.1, C3.1, C4.1, D3.1, J1.2, L1.1, U1.6
XD: J3.1, R3.2, R4.1

## KiCad design pcb/TX_advanced/TX_advanced.kicad_pcb

Board: 2 copper layers, 85.0 x 60.0 mm, 32 parts (0 on the bottom side), 17 nets.

Parts:
C1: 100u/25V; CP_Elec_6.3x7.7
C2, C5: 100n; C_0805_2012Metric
C3, C4: 1n/2kV; C_1206_3216Metric
D1, D2: BZT52C15S; D_SOD-323
D3, D4: SMBJ40A; D_SMB
D9: SMBJ15A; D_SMB
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1: 12V_IN; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2: PWM_IN; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J3: TD04A; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
L1: 470uH; L_Radial_D10.0mm_P5.00mm_Fastron_07M
Q1, Q2: 2SK4017; TO-251-3_Vertical
R1, R2: 100; R_0805_2012Metric
R3, R4: 10; R_0805_2012Metric
R5, R6: 10k; R_0805_2012Metric
R7, R8: 100; R_1206_3216Metric
R9: 220; R_2512_6332Metric
R10: 100k; R_1206_3216Metric
T1: XFMR_CT_1to5; PinHeader_1x05_P2.54mm_Vertical
U1: TC4427A; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
GA: D1.1, Q1.1, R3.2, R5.1
GB: D2.1, Q2.1, R4.2, R6.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D1.2, D2.2, D3.2, D4.2, D9.2, J1.1, J2.3, J3.2, Q1.3, Q2.3, R5.2, R6.2, R10.2, T1.5, U1.3
INA: R1.2, U1.2
INB: R2.2, U1.4
OUTA: R3.1, U1.7
OUTB: R4.1, U1.5
PA: D3.1, Q1.2, R7.1, T1.1
PB: D4.1, Q2.2, R8.1, T1.3
PWMA_IN: J2.1, R1.1
PWMB_IN: J2.2, R2.1
SEC: L1.1, T1.4
SNA: C3.1, R7.2
SNB: C4.1, R8.2
V12: C1.1, C2.1, C5.1, D9.1, J1.2, T1.2, U1.6
XD: J3.1, R9.2, R10.1
XDRV: L1.2, R9.1

## KiCad design pcb/UI_BOARD/UI_BOARD.kicad_pcb

Parts:
C_LCD: 100n; C_Disc_D5.0mm_W2.5mm_P5.00mm
C_RST: 100n; C_Disc_D5.0mm_W2.5mm_P5.00mm
H1, H2: M3; MountingHole_3.2mm_M3
J_LCD1: NHD_C12864WO; PinHeader_1x09_P2.54mm_Vertical
J_MAIN1: TO_MAIN; JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
Q_BL: 2SK4017; TO-92_Inline
R_BL: 33; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R_D: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R_E: 3.3k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R_G: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R_GPD: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R_LAD: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R_RST: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW_DN: DOWN; SW_PUSH_6mm
SW_ENT: ENTER; SW_PUSH_6mm
SW_UP: UP; SW_PUSH_6mm

Connections:
BL_GATE: Q_BL.1 (G), R_G.2, R_GPD.1
BL_PWM: J_MAIN1.7, R_G.1
BTN_ADC: J_MAIN1.8, R_LAD.2, SW_DN.1, SW_ENT.1, SW_UP.1
GND: C_LCD.2, C_RST.2, J_LCD1.1, J_MAIN1.2, Q_BL.3 (S), R_D.2, R_E.2, R_GPD.2, SW_UP.2
LCD_CS: J_LCD1.5, J_MAIN1.5
LCD_DC: J_LCD1.6, J_MAIN1.6
LCD_RST: C_RST.1, J_LCD1.7, R_RST.2
LEDBL_A: J_LCD1.8, R_BL.2
LEDBL_K: J_LCD1.9, Q_BL.2 (D)
N_D: R_D.1, SW_DN.2
N_E: R_E.1, SW_ENT.2
SPI_MOSI: J_LCD1.4, J_MAIN1.4
SPI_SCK: J_LCD1.3, J_MAIN1.3
V3D: C_LCD.1, J_LCD1.2, J_MAIN1.1, R_BL.1, R_LAD.1, R_RST.1

Board: 2 copper layers, 100.0 x 65.0 mm, 17 parts (0 on the bottom side), 14 nets.

## KiCad design pcb/_test/testgen.kicad_pcb

Board: 2 copper layers, 55.0 x 50.0 mm, 6 parts (0 on the bottom side), 5 nets, no tracks yet.

Parts:
D1: D_DO-35_SOD27_P7.62mm_Horizontal
R1, R2, R3, R4: R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: SOT-23-6

Connections:
GND: D1.1, R4.2, U1.2
N1: D1.2, R1.1, U1.1
N2: R1.2, R2.1, U1.3
N3: R2.2, R3.1, U1.5
N4: R3.2, R4.1, U1.6
